# Keil uVision project 比赛计时器.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 比赛计时器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c headfile.h
  group New Group
    ./: user.c user.h LYX_Nixie_tube.c LYX_Nixie_tube.h LYX_Delays.h LYX_Delays.c
